# to avoid incompatible with host aarch64-wrs-linux
COMPATIBLE_HOST:ti-j7 = "${HOST_SYS}"
COMPATIBLE_MACHINE:ti-j7 = "ti-j7"
