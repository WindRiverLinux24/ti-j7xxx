COMPATIBLE_MACHINE:ti-j7 = "ti-j7"
SPL_BINARY:ti-j7 = "tispl.bin"
PACKAGECONFIG:append:ti-j7 = " atf optee dm"

SRCREV:ti-j7 = "bd74e615a689936981342a3bd0b018a3da125a66"
