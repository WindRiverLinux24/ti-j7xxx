COMPATIBLE_MACHINE:ti-j7 = "ti-j7"
