require linux-yocto-ti-j7xxx.inc

KBRANCH:ti-j7 = "v6.1/standard/preempt-rt/ti-sdk-5.10/ti-j7xxx"

