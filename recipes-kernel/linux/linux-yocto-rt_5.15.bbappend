require linux-yocto-ti-j7xxx.inc

KBRANCH:ti-j7 = "v5.15/standard/preempt-rt/ti-sdk-5.10/ti-j72xx"

