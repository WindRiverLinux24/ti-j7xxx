require linux-yocto-ti-j7xxx.inc

KBRANCH:ti-j7 = "v6.6/standard/preempt-rt/ti-sdk-6.6/ti-soc"

